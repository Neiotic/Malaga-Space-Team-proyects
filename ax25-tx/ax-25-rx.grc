options:
  parameters:
    author: Javi B
    generate_options: qt_gui
    id: ax25_rx
    output_language: python
    title: AX.25 BFSK Reciever
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: (2 * math.pi * deviation) / samp_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / bitrate)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*deviation)
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: rx.bin
    type: byte
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: rx_sliced.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ax25_bfsk_tx.iq
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    log_level: debug
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '1'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='AX.25 ASCII Decoder',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              
              # Puerto de entrada de mensajes
              self.message_port_register_in(pmt.intern("in"))

              # Puerto de salida de mensajes
              self.message_port_register_out(pmt.intern("out"))

              self.set_msg_handler(
                  pmt.intern("in"),
                  self.handle_msg
              )


          def handle_msg(self, msg):

              # El PDU tiene:
              # msg = pair(metadata, data)
              data = pmt.cdr(msg)

              # Convertimos el vector PMT a bytes
              data_bytes = bytes(pmt.u8vector_elements(data))

              # Cabecera AX.25:
              # 7 bytes destino
              # 7 bytes origen
              # 1 byte control
              # 1 byte PID
              # ----------------
              # 16 bytes
              payload = data_bytes[16:]

              # Convertir payload a ASCII
              text = payload.decode("ascii", errors="replace")

              print("================================")
              print("AX.25 PAYLOAD:")
              print(text)
              print("================================")

              # Mandar el texto como PDU al siguiente bloque
              text_bytes = text.encode("ascii", errors="replace")

              out_vector = pmt.init_u8vector(
                  len(text_bytes),
                  list(text_bytes)
              )

              self.message_port_pub(
                  pmt.intern("out"),
                  pmt.cons(pmt.PMT_NIL, out_vector)
              )
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: A partir de aquí ya está decodificado el mensaje
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_1_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_hdlc_deframer_bp_0, out, epy_block_0, in]
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_0, out, blocks_message_debug_0, print]
- [satellites_nrzi_decode_0, '0', blocks_file_sink_1, '0']
- [satellites_nrzi_decode_0, '0', digital_hdlc_deframer_bp_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
