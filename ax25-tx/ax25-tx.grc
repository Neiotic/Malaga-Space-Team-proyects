options:
  parameters:
    author: Diego
    generate_options: qt_gui
    id: ax25_tx
    output_language: python
    title: AX.25 BFSK Transmitter
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: (2 * math.pi * deviation) / samp_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / bitrate)
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: sensitivity
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ax25_bfsk_tx.iq
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: tx.bin
    type: byte
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: tx_2.bin
    type: byte
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("ESTO ES UNA PRUEBA PARA EL DESCODIFICADOR")
    period: '2000'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: float
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (-1.0, 1.0)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          """AX.25 UI Frame Builder block.
          Takes input messages (string or u8vector), wraps them in AX.25 UI frame,
          and publishes the frame as a byte PDU."""
          def __init__(self, dest_call='DEST', dest_ssid=0, src_call='SRC', src_ssid=0):
              gr.basic_block.__init__(
                  self,
                  name='AX.25 Frame Builder',
                  in_sig=None,
                  out_sig=None
              )
              self.dest_call = dest_call
              self.dest_ssid = dest_ssid
              self.src_call = src_call
              self.src_ssid = src_ssid
              
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)
              self.message_port_register_out(pmt.intern('out'))

          def encode_address(self, callsign, ssid, is_last):
              # Pad callsign to 6 characters
              call = callsign.upper().ljust(6)[:6]
              encoded = []
              for char in call:
                  encoded.append(ord(char) << 1)
              # SSID byte: 0x60 | (ssid << 1) | (1 if is_last else 0)
              ssid_byte = 0x60 | ((ssid & 0x0F) << 1) | (1 if is_last else 0)
              encoded.append(ssid_byte)
              return bytes(encoded)

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  payload_pmt = pmt.cdr(msg_pmt)
              else:
                  meta = pmt.make_dict()
                  payload_pmt = msg_pmt

              if pmt.is_u8vector(payload_pmt):
                  payload = bytes(pmt.u8vector_elements(payload_pmt))
              elif pmt.is_symbol(payload_pmt) or pmt.is_string(payload_pmt):
                  payload = pmt.to_python(payload_pmt).encode('utf-8')
              else:
                  try:
                      payload = str(pmt.to_python(payload_pmt)).encode('utf-8')
                  except Exception:
                      return

              dest_addr = self.encode_address(self.dest_call, self.dest_ssid, False)
              src_addr = self.encode_address(self.src_call, self.src_ssid, True)
              control = b'\x03' # UI Frame
              pid = b'\xF0'     # No layer 3 protocol
              
              frame = dest_addr + src_addr + control + pid + payload
              
              out_msg = pmt.cons(meta, pmt.init_u8vector(len(frame), list(frame)))
              self.message_port_pub(pmt.intern('out'), out_msg)
    dest_call: '"DEST"'
    dest_ssid: '0'
    src_call: '"SRC"'
    src_ssid: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Baseband Spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: TX Real (I)
    label2: TX Imag (Q)
    name: '"Baseband Transmitted Signal"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '7'
    preamble_bytes: '50'
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ax25
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ax25
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_file_sink_0, '0']
- [analog_frequency_modulator_fc_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_frequency_modulator_fc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_0, in]
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [epy_block_0, out, satellites_hdlc_framer_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', satellites_nrzi_encode_0, '0']
- [satellites_hdlc_framer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_nrzi_encode_0, '0', blocks_char_to_float_0_0, '0']
- [satellites_nrzi_encode_0, '0', blocks_file_sink_1, '0']
- [satellites_nrzi_encode_0, '0', blocks_file_sink_2, '0']
- [satellites_nrzi_encode_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', digital_chunks_to_symbols_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
